## tests/anomaly_detector/testcase.yaml
```yaml
tests:
  zlab.anomaly_detector:
    platform_allow:
      - native_sim/native/64
    tags:
      - zlab
      - unit
```
